# Keil uVision project N32G003.uvprojx, settings and files
target N32G003 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32G003F5 Nationstech
  pack: Nationstech.N32G003_DFP.1.0.1
  cpu: IRAM(0x20000000,0x0C00) IROM(0x08000000,0x7600) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: N32G003_SelfTest +hex
  AfterMake: fromelf.exe --bin --output .\Listings\@L.bin !L
  AfterMake: srecord_crc32.bat
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: N32G003,USE_STDPERIPH_DRIVER
  c include: ..\N32_SelfTest_Library\inc;..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\firmware\n32g003_std_periph_driver\inc;..\..\ClassB_demo
  asm define: ARTISAN=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x7600
  memory RVCT9: RAM 0x20000000 size 0xc00
  scatter file: .\N32G003_SelfTest.sct
  group User
    ../: main.c n32g0xx_it.c crc32_software.c
  group CMSIS
    ../../../../../firmware/CMSIS/device/startup/: startup_n32g003.s
    ../../../../../firmware/CMSIS/device/: system_n32g003.c
  group N32_SelfTest_Code
    ./: n32g0xx_STLcpurunKEIL.s n32g0xx_STLcpustartKEIL.s n32g0xx_STLRamMcMxKEIL.s
  group N32_SelfTest_Library
    ../N32_SelfTest_Library/src/: n32g0xx_STLclockrun.c n32g0xx_STLclockstart.c n32g0xx_STLcrc32Run.c n32g0xx_STLmain.c n32g0xx_STLstartup.c n32g0xx_STLtranspRam.c
  group N32G003_Periph
    ../../../../../firmware/n32g003_std_periph_driver/src/: misc.c n32g003_crc.c n32g003_dbg.c n32g003_flash.c n32g003_gpio.c n32g003_iwdg.c n32g003_pwr.c n32g003_rcc.c n32g003_uart.c
